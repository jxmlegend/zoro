# Keil uVision project LED.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LED +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\motor;..\HARDWARE\XUNJI;..\HARDWARE\XUNJI;..\HARDWARE\color_sensor;..\HARDWARE\color_sensor(IO_PB);..\SYSTEM\usart;..\HARDWARE\ZigBee;..\HARDWARE\SPI;..\HARDWARE\NRF24L01;..\HARDWARE\RC;..\HARDWARE\Infrared_Sensor;..\HARDWARE\KEY;..\HARDWARE\BH1750;..\HARDWARE\color_sensor;..\HARDWARE\HC-SR04
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/motor/: motor_pwm.c
    ../HARDWARE/XUNJI/: xunji.c
    ../HARDWARE/ZigBee/: ZigBee.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/RC/: RC.c
    ../HARDWARE/NRF24L01/: 24l01.c
    ../HARDWARE/Infrared_Sensor/: Infrared_emsiion.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/BH1750/: bh1750.c i2c.c
    ../HARDWARE/color_sensor(IO_PB)/: color_sensor.c
    ../HARDWARE/HC-SR04/: HCSR04.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_tim.c stm32f10x_spi.c stm32f10x_exti.c
