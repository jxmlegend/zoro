# Keil uVision project test.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=4
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\USER;..\FWLib\inc;..\CMSIS;..\MY\inc;..\MY\PWM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c
  group FWLib
    ../FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group STARTUP
    ../CMSIS/startup/arm/: startup_stm32f10x_hd.s
  group MY
    ../MY/delay/: delay.c
    ../MY/timer/: timer.c
    ../MY/usart/: usart.c
    ../MY/adc/: adc.c
    ../MY/PWM/: pwm.c
software components: CMSIS:CORE 4.1.0
