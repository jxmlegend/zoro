# Keil uVision project renwu_nrf24l01.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: renwu_nrf24l01 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\src\nrf24l01;..\src\ADC;..\src\color_sensor;..\src\delay;..\src\DHT11;..\src\FM_ctrl;..\src\Infrared Sensor;..\src\light;..\src\motor;..\src\uart;..\src\user;..\src\HCSR04
  group User
    ./: STARTUP.A51
    ../src/user/: main.c
    ../src/uart/: uart.c
    ../src/delay/: delay.c
  group Hardware
    ../src/motor/: motor_xunji.c motor.c STC12C5A60S2_PWM.c
    ../src/ADC/: ADC.c
    ../src/color_sensor/: color_sensor.c
    ../src/DHT11/: dht11.c
    ../src/Infrared Sensor/: Infrared_emission.c IR_delay.c
    ../src/light/: STC_BH1750_nicete.c
    ../src/nrf24l01/: RC.c NRF24L01.C
    ../src/HCSR04/: HCSR04.c
  group ReadMe
    ../: 51主控板IO口分配.txt
